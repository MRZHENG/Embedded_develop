# Keil uVision project LED.uvprojx, settings and files
target 基本定时器 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TIM +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\CMSIS;.\FWlib\inc;.\USER;.\USER\LED_DEMO;.\USER\_USART1-DEMO;.\USER\DMA_DEMO;.\CMSIS;.\FWlib\inc;.\USER;.\USER\_USART1-DEMO;.\USER\DMA_DEMO;.\USER\LED_DEMO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ./STARTUP/: startup_stm32f10x_hd.s
  group USER
    ./USER/: main.c led.c stm32f10x_it.c bsp_key.c usart1.c BasicTIM.c
    ./USER/DMA_DEMO/: bsp_DMA_mtm.c bsp_DMA_mtp.c
  group FWilb
    ./FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_tim.c misc.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
